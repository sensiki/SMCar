# Keil uVision project motor_con.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F32XE STC11F32XE Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: motor_con +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\电机控制
  group Source
    ./Source/: main.c motor.c timer.c uart.c config.h motor.h STC_NEW_8051.H steer.h timer.h type.h uart.h SelfTest.c SelfTest.h mem.h IR.h codetab.h OLED12864.c
  group lib
    ./lib/: STEER.LIB IR.LIB MEM.LIB
